Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_90.304_TORNEIRA_CLEAN_BANCADA_ON-OFF.IFC
Time: 2023-05-26T12:02:45
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DRACO_070.335_TORNEIRA_CLEAN_BANCADA_BICA
In: Default Storey
Material: Brass

# IfcBuildingElementProxy: DRACO_502.837_CANOPLA_TORNEIRA_CLEAN_BANCADA_REV.01_Default
In: Default Storey
Material: Brass

# IfcBuildingElementProxy: DRACO_60.334_TORNEIRA CLEAN_BANCADA_BASE_SEM_CONECTOR
In: Default Storey
Material: Latão
